# Keil uVision project HeapTester.uvprojx, settings and files
target HeapTester (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HeapTester
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR LAB5
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab5.def
  group Source
    ./: startup.s HeapTester.c
    ../inc/: LaunchPad.c WTimer0A.c Timer1A.c Timer2A.c Timer5A.c PLL.c
    ../RTOS_Labs_common/: OS.c ST7735.c UART0int.c osasm.s heap.c heapbestfit.c heapfirstfit.c heapknuth.c heapworstfit.c FIFOsimple.c eDisk.c
